/**
 *  @file		HeaterCalcificationDetectionMonitor.c
 *
 *  @brief      Wrapper for the code generated HeaterCalcificationDetection
 *
 *  @details
 *
 *  @section    Applicable_Documents
 *					List here all the applicable documents if needed. <tr>
 *
 *  $Header: $
 *
 *  @copyright  Copyright 2018-2019. Whirlpool Corporation. All rights reserved - CONFIDENTIAL
 */
//---------------------------------------------------------------------------------------------------------------------
//---------------------------------------------------------------------------------------------------------------------


//-------------------------------------- Include Files ----------------------------------------------------------------
#include "HeaterCalcificationDetectionMonitor.h"

// -- Other Modules --
#include "Hbl.h"
#include "Log.h"
#include "HeatMonitor.h"
#include "Micro.h"
#include "NVData.h"
#include "Regulations.h"
#include "SaltSensingMonitor.h"
#include "StatisticsDish.h"
#include "SettingFile.h"
#include "string.h"
#include "Variable.h"
#include "Vwi.h"
#include "WashHeaterFaultMonitor.h"

//-------------------------------------- PUBLIC (Variables) -----------------------------------------------------------

//! Heater Calcification Bitmap
#pragma location = "_appliance_segment"
HCD_BITMAP_TYPE HCD_Bitmap;

//! Data to be shared with HMI
#pragma location = "_appliance_segment"
HCD_HMI_DATA_TYPE HCD_HMI_Data;

//! Heater Calcification Level
#pragma location = "_appliance_segment"
uint8 HCD_Calcification_Level;

//! Amount of clicks occurred in water stable condition
uint16 HCD_Heater_Clicks;

//! Exported model data
#pragma location = "_appliance_segment"
HCD_MODELDATA_TYPE HCD_ModelData;

//-------------------------------------- PRIVATE (Variables, Constants & Defines) -------------------------------------

//! The name of this module for use by the Log module.
#define MODULE_NAME MODULE_HCD_MONITOR

//! A list of log message IDs that are generated by this module.
typedef enum MODULE_HCD_MONITOR_LOG_MESSAGE_ID_ENUM
{
	ERROR_LOADING_PARAMETERS       = 1,
	ERROR_MISSING_PARAMETERS
} MODULE_HCD_MONITOR_LOG_MESSAGE_ID_TYPE;

//! Maximum allowed number of Heater Calcification levels
#define MAX_CALCIFICATION_LEVELS_NUM	(uint8)7

//! Number of heater current thresholds in setting file
#define HEATER_CURRENT_THRESHOLDS_NUM	(uint8)6

//! A structure definition for the counters used by the algorithm
typedef struct HCD_COUNTERS_STRUCT
{
    uint8 Alarm_Counter;
    uint8 Reduction_Counter;
    uint8 Lockout_Counter;
    uint8 Periodic_HT_Counter;
    uint8 Cycles_Remaining;
} HCD_COUNTERS_TYPE;

//! Boolean variable to enable and disable Heater Calcification Detection execution
#pragma location = "_appliance_segment"
static BOOL_TYPE HCD_Enable;

//! Start of cycle indicator
static BOOL_TYPE HCD_Cycle_Started;

//! Boolean indicating if the Heater Calcification Detection is active or not
static BOOL_TYPE HCD_Is_Active;

//! Position of the Water Hardness function
static uint8 WHS_Function_Position;

//! Amount of increase of Water Hardness regulation
#pragma location = "_appliance_segment"
static uint8 HCD_WHS_Increased_By;

//! Number of rows in the array
static uint8 SF_Calcification_Levels_Number;

//! Pointer to setting file parameters
static HEATER_CALCIFICATION_PARAMS_TYPE *SF_HCD_Parameters;
//! Pointer to setting file level dependent parameters
static HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE *SF_HCD_Lvl_Parameters;
//! Pointer to the Heater Sensing parameters in Setting File
static HEATER_CURRENT_SENSING_PARAMS_TYPE *Heater_Sensing_Paramters_Ptr;

//! Fixed heater current threshold for Heater Click detection
static uint16 HCD_Heater_Current_Threshold;

//! The highest Calcification Level with "0" set as Lockout Threshold.
static uint8 HCD_Highest_CL_Without_Lockout;

//! The lowest non-zero Lockout Threshold (or 0 if such a value does not exist).
static uint8 HCD_Lowest_Lockout_Thr;

//! Array of temperature thresholds interpolated for HCD_Lowest_Click_Current (static for debug purpose)
static uint16 HCD_Lowest_Click_Current_Thresholds[MAX_CALCIFICATION_LEVELS_NUM];

//! Array of temperature thresholds interpolated for HCD_Reduction_Current (static for debug purpose)
static uint16 HCD_Reduction_Current_Thresholds[MAX_CALCIFICATION_LEVELS_NUM];

static uint16 HCD_Lowest_Click_Temperature;
static uint16 HCD_Lowest_Click_Current;
static uint16 HCD_Lowest_Click_Power;
static uint16 HCD_Reduction_Temperature;
static uint16 HCD_Reduction_Current;
static uint16 HCD_Reduction_Power;

//! A structure for the counters used by the algorithm
#pragma location = "_appliance_segment"
static HCD_COUNTERS_TYPE HCD_Counters;

//! Current/last model state
#pragma location = "_appliance_segment"
static HCD_MONITORSTATE_TYPE HCD_Monitoring_States;

//! Model Data
static RT_MODELHEATERCALCIFICATIO_TYPE HeaterCalcificationDetection_RTModelData_;
static RT_MODELHEATERCALCIFICATIO_TYPE *const HeaterCalcificationDetection_RTModelData = &HeaterCalcificationDetection_RTModelData_;/* Real-time model */
/*#pragma location = "_appliance_segment"*/
static DWHEATERCALCIFICATIONDETEC_TYPE HeaterCalcificationDetection_ObservableStates;/* Observable states */

//-------------------------------------- PRIVATE (Function Prototypes) ------------------------------------------------

static void HeaterCalcificationDetectionModelSetup(void);
static void TemperatureThresholdsInterpolation(uint16 input_current, uint16 *interpolated_thresholds);
static void UpdateParamsPointerAndAlignCountersToThresholds(const HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE **current_level_params_ptr);

//=====================================================================================================================
//-------------------------------------- Public Functions -------------------------------------------------------------
//=====================================================================================================================

// General Set functions
uint16 HeaterCalcificationDetectionMonitor__GetHeaterClicks(void)
{
	return HCD_Heater_Clicks;
}

void HeaterCalcificationDetectionMonitor__SetHeaterClicks(uint16 heaterClicks)
{
    HCD_Heater_Clicks = heaterClicks;
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__Initialize
 *  @details    Function used to initialize the monitor.
 *
 */
void HeaterCalcificationDetectionMonitor__Initialize()
{
    uint8 heater_current_gi_index;
	uint8 wash_heater_index;
	SETTINGFILE_LOADER_TYPE loader;
	//HCD_MODELDATA_TYPE hcd_backup_memory;
    
    Heater_Sensing_Paramters_Ptr = (HEATER_CURRENT_SENSING_PARAMS_TYPE *)NULL;

	if (Micro__GetResetMode() == MICRO_RESET_MODE_COLD)
	{
		HCD_Is_Active = FALSE;
		SF_Calcification_Levels_Number = 0;
		HCD_Lowest_Lockout_Thr = 0;
		HCD_Highest_CL_Without_Lockout = 0;

		memset(&HCD_Lowest_Click_Current_Thresholds[0], 0, sizeof(HCD_Lowest_Click_Current_Thresholds));
		memset(&HCD_Reduction_Current_Thresholds[0], 0, sizeof(HCD_Reduction_Current_Thresholds));

		SF_HCD_Parameters = NULL;
		SF_HCD_Lvl_Parameters = NULL;

		// Load parameters from setting file
		if (SettingFile__BasicLoader(SF_PTR_ACU_ALGORITHM_PARAMETERS, DISPL_HEATER_CALCIFICATION, &loader) == PASS)
		{
			SF_HCD_Parameters = (HEATER_CALCIFICATION_PARAMS_TYPE*)(void*)(loader.Data); // Read the data from the setting file

			if(SettingFile__BasicLoader(SF_PTR_ACU_ALGORITHM_PARAMETERS, DISPL_HEATER_CALCIFICATION_LEVEL_DIP_PARAMS, &loader) == PASS)
			{
				uint8 i;
				const HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE *current_level_params_ptr;

				SF_HCD_Lvl_Parameters = (HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE*)(void*)(loader.Data);

				SF_Calcification_Levels_Number = (uint8)(loader.Length / sizeof(HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE));

				if (SF_Calcification_Levels_Number > MAX_CALCIFICATION_LEVELS_NUM)
				{
					// This is the maximum number of calcification levels managed by the algorithm
					SF_Calcification_Levels_Number = MAX_CALCIFICATION_LEVELS_NUM;
				}


				for (i = 0; i < SF_Calcification_Levels_Number; i++)
				{
					current_level_params_ptr = SF_HCD_Lvl_Parameters + i;

					if (current_level_params_ptr->Lockout_Threshold == (uint8)0)
					{
						// Highest_CL_With_No_Lockout is defined as the highest Calcification Level with "0" set as Lockout Threshold.
						HCD_Highest_CL_Without_Lockout = i;
					}
					else
					{
						// HCD_Lowest_Lockout_Thr is defined as the lowest non-zero Lockout Threshold, or 0 if such a value does not exist,
						// in other words it is the Lockout_Threshold for the highest Calcification Level.
						HCD_Lowest_Lockout_Thr = current_level_params_ptr->Lockout_Threshold;
					}
				}

				heater_current_gi_index = Hbl__GetGIIndexByGIID(HBL_GI_I_HEATER);
				wash_heater_index = Hbl__GetLoadIndexByLoadID(HBL_LOAD_WASHING_HEATER);

				if((heater_current_gi_index != (uint8)HBL_INDEX_INVALID) && (wash_heater_index != (uint8)HBL_INDEX_INVALID))
				{
					if (SettingFile__BasicLoader(SF_PTR_ACU_PRODUCT_CONFIGURATION_DATA,	DISPL_HEATER_DEACTIVATION_CONDITIONS_PARAM, &loader) == PASS)
					{
						if (((HEAT_MONITOR_INSTANCE_TYPE *)(void*)loader.Data)->Heater_Type == (uint8)INTEGRATED_HEATER)
						{
                            // Integrated Heater type - run the algorithm
							HCD_Is_Active = TRUE;
						}
						else
						{
							// HCD algorithm doesn't apply to Calrod Heater type.
						}
					}
					else
					{
						// It is not possible to know the heater's type
						LOG_ADD_EXCEPTION(ERROR_MISSING_PARAMETERS, DISPL_HEATER_DEACTIVATION_CONDITIONS_PARAM);
					}
                    if (SettingFile__BasicLoader(SF_PTR_ACU_PRODUCT_CONFIGURATION_DATA, DSPL_HEATER_CURRENT_SENSING_PARAMS, &loader) == PASS)
                    {
                        Heater_Sensing_Paramters_Ptr = (HEATER_CURRENT_SENSING_PARAMS_TYPE *)loader.Data; //lint !e927 Suppress Info: cast from pointer to pointer [MISRA 2004 Rule 11.4]
                        HCD_Heater_Current_Threshold = Heater_Sensing_Paramters_Ptr->Heater_Off_Threshold;
                    }
                    else
                    {
                        LOG_ADD_EXCEPTION (ERROR_MISSING_PARAMETERS, 0);
                    }
                }
			}
			else
			{
				// There is no Heater Calcification Level Parameters section in SF
				LOG_ADD_EXCEPTION(ERROR_LOADING_PARAMETERS, SF_PTR_ACU_PRODUCT_CONFIGURATION_DATA);
			}
		}
		else
		{
			// There is no Heater Calcification Parameters section in SF
			LOG_ADD_EXCEPTION(ERROR_LOADING_PARAMETERS, SF_PTR_ACU_ALGORITHM_PARAMETERS);
		}
   
		HCD_Cycle_Started = FALSE;
        HCD_Heater_Clicks = 0;
		HCD_Lowest_Click_Temperature = FIXED_POINT_99C;
		HCD_Lowest_Click_Current = 0;
		HCD_Lowest_Click_Power = 0;
		HCD_Reduction_Temperature = 0;
		HCD_Reduction_Current = 0;
		HCD_Reduction_Power = 0;

		WHS_Function_Position = Regulations__GetPositionByFunctionID(FUNC_ID_WATER_HARDNESS_LEVEL, COMPARTMENT_DEFAULT);

		if (NVData__GetLastRestoreStatus()->Bit.Appliance_Data_Recovered != (NVDATA_RESTORE_TYPE)NVDATA_RESTORE_OKAY)
		{
			memset(&HCD_HMI_Data, 0, sizeof(HCD_HMI_Data));
			HCD_Bitmap.All = 0;

			memset(&HCD_Counters, 0, sizeof(HCD_Counters));

			HCD_Calcification_Level = 0;
			HCD_Enable = FALSE;
			HCD_WHS_Increased_By = 0;
            
			memset(&HCD_ModelData, 0, sizeof(HCD_ModelData));
			HCD_ModelData.Lowest_Click_Temperature = FIXED_POINT_99C;
			memset(&HCD_Monitoring_States, 0, sizeof(HCD_Monitoring_States));
		}
		else
		{
/** Part of previous structure - no more applicable            
 			//! Backup of the model data before memory reset
 			hcd_backup_memory = HeaterCalcificationDetection_ObservableStates.hcd_mastermodel_instancedata.rtdw.hcd_modeldata;
 */
		}

		// Reset all state machine states
		memset(&HeaterCalcificationDetection_ObservableStates,0,sizeof(HeaterCalcificationDetection_ObservableStates));

/** Part of previous structure - no more applicable
		// Restore the model data backup
		HeaterCalcificationDetection_ObservableStates.hcd_mastermodel_instancedata.rtdw.hcd_modeldata = hcd_backup_memory;
 */

		if ((uint8)HCD_Is_Active == (uint8)TRUE)
		{
			HeaterCalcificationDetectionModelSetup();
		}
		else
		{
			HeaterCalcificationDetection_RTModelData->dwork = &HeaterCalcificationDetection_ObservableStates;
		}
	}
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__Execution
 *  @details    Function used to perform the monitor.
 *
 */
void HeaterCalcificationDetectionMonitor__Execution(void)
{
    if ((uint8)HCD_Is_Active == (uint8)TRUE)
	{
        HeaterCalcificationDetectionMaster__Execute(HeaterCalcificationDetection_RTModelData,HCD_Enable,HCD_Heater_Current_Threshold,SF_HCD_Parameters,HCD_Cycle_Started,
					&HCD_Lowest_Click_Temperature,&HCD_Lowest_Click_Current,&HCD_Lowest_Click_Power,&HCD_Reduction_Temperature,&HCD_Reduction_Current,&HCD_Reduction_Power,&HCD_Monitoring_States);
    }
    
	if ((WHS_Function_Position != (uint8)REGULATION_INVALID) && ((uint8)Regulations__IsRegulationChanged(WHS_Function_Position) == (uint8)TRUE))
	{
		if ((uint8)HCD_HMI_Data.Flags.Increase_WHS != (uint8)0)
		{
			HCD_HMI_Data.Flags.Increase_WHS = FALSE;
		}
		else
		{
			HCD_WHS_Increased_By = 0;
		}
	}
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__Start
 *  @details    Function used to enable the Heater Calcification Detection monitor.
 *
 */
void HeaterCalcificationDetectionMonitor__Start(void)
{
	if((uint8)HCD_Is_Active == (uint8)TRUE)
	{
        HCD_Enable = TRUE;
    }
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__Stop
 *  @details    Function used to disable the Heater Calcification Detection monitor.
 *
 */
void HeaterCalcificationDetectionMonitor__Stop(void)
{
	HCD_Enable = FALSE;
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__Reset
 *  @details    Function used to reset the Heater Calcification Detection monitor.
 *
 */
void HeaterCalcificationDetectionMonitor__Reset(void)
{
	if((uint8)HCD_Is_Active == (uint8)TRUE)
	{
		HeaterCalcificationDetectionModelSetup();
        
		HCD_Cycle_Started = FALSE;
	}
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__CycleStarted
 *  @details    Function used to reset the local parameters inside Heater Calcification Detection model
 *				when a new cycle is started.
 */
void HeaterCalcificationDetectionMonitor__CycleStarted(void)
{
	if((uint8)HCD_Is_Active == (uint8)TRUE)
	{
		HCD_Cycle_Started = TRUE;

		HCD_HMI_Data.Flags.Increase_WHS = FALSE;
	}
}

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionMonitor__CycleEnded
 *  @details    Function used to perform the actions required by Heater Calcification Detection algorithm
 *				when a cycle ends.
 */
void HeaterCalcificationDetectionMonitor__CycleEnded(void)
{
	if((uint8)HCD_Is_Active == (uint8)TRUE)
    {
		uint8 max_calcification_level;
		BOOL_TYPE calcification_level_increased = FALSE;
		const HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE *current_level_params_ptr;
		BOOL_TYPE manage_consistent_lockout_countdown = FALSE;
		BOOL_TYPE increase_WHS = FALSE;

	    // Calculate max allowed value for HCD_Calcification_Level, based on setting file parameters.
	    if (SF_Calcification_Levels_Number > (uint8)0)
	    {
	    	max_calcification_level = SF_Calcification_Levels_Number - (uint8)1;
	    }
	    else
	    {
	    	max_calcification_level = 0;
	    }

		// Reset interpolated thresholds
	    memset(&HCD_Lowest_Click_Current_Thresholds[0], 0, sizeof(HCD_Lowest_Click_Current_Thresholds));
		memset(&HCD_Reduction_Current_Thresholds[0], 0, sizeof(HCD_Reduction_Current_Thresholds));

		// ********************************************************************************
	    // Start of end of cycle calculations for Heater Calcification detection algorithm
	    // ********************************************************************************

	    if (HCD_Heater_Clicks > ENDIANU16_STON(SF_HCD_Parameters->Allowed_Clicks_Num))
		{
	    	// *** Full Increase ***

	    	// Calculate interpolated temperature thresholds for Lowest Click Current
	    	TemperatureThresholdsInterpolation(HCD_Lowest_Click_Current, HCD_Lowest_Click_Current_Thresholds);

			// HCD_Calcification_Level update
	    	while ((HCD_Calcification_Level < max_calcification_level) && (HCD_Lowest_Click_Temperature <= HCD_Lowest_Click_Current_Thresholds[HCD_Calcification_Level + (uint8)1]))
			{
				HCD_Calcification_Level ++;
				HCD_Counters.Lockout_Counter = 0;
				calcification_level_increased = TRUE;
			}

			HCD_Counters.Reduction_Counter = 0;
		}

        // Update pointer to the set of parameters correspondent to the current HCD_Calcification_Level
	    UpdateParamsPointerAndAlignCountersToThresholds(&current_level_params_ptr);

		if (HCD_Heater_Clicks <= SF_HCD_Parameters->Allowed_Clicks_To_Reduce)
		{
	    	// *** Limited Reduction ***

			if(current_level_params_ptr->Calcification_Reduction_Threshold > (uint8)0)
			{
				// Increase Reduction Counter
				if (HCD_Counters.Reduction_Counter < current_level_params_ptr->Calcification_Reduction_Threshold)
				{
					HCD_Counters.Reduction_Counter ++;
				}

				if (HCD_Counters.Reduction_Counter >= current_level_params_ptr->Calcification_Reduction_Threshold)
				{
					if (HCD_Calcification_Level > (uint8)0)
					{
						if (current_level_params_ptr->Lockout_Threshold == (uint8)0)
						{
							HCD_Calcification_Level --;
						}
						else
						{
							HCD_Calcification_Level = HCD_Highest_CL_Without_Lockout;
						}

						// Update pointer to the set of parameters correspondent to the current HCD_Calcification_Level
						UpdateParamsPointerAndAlignCountersToThresholds(&current_level_params_ptr);
					}

					// Reset Reduction Counter
					HCD_Counters.Reduction_Counter = 0;
				}
			}
			else
			{
		    	// If a particular threshold equals zero, then any counter relying on this threshold should be kept at 0
		    	// and no events related to that threshold should be triggered.
			}

	    	// *** Full Reduction ***

	    	// Calculate interpolated temperature thresholds for Reduction Current
			TemperatureThresholdsInterpolation(HCD_Reduction_Current, HCD_Reduction_Current_Thresholds);

			while ((HCD_Calcification_Level > (uint8)0) && (HCD_Reduction_Temperature > HCD_Reduction_Current_Thresholds[HCD_Calcification_Level]))
			{
				HCD_Calcification_Level --;

				// Don't update current_level_params_ptr, keep the current one
			}

			if (HCD_Calcification_Level > HCD_Highest_CL_Without_Lockout)
			{
				manage_consistent_lockout_countdown = TRUE;
			}
		}
		else
		{
			// Increase Lockout Counter if it is lower than its	Threshold
			if (HCD_Counters.Lockout_Counter < current_level_params_ptr->Lockout_Threshold)
			{
				HCD_Counters.Lockout_Counter ++;
			}

	    	// *** Limited Increase ***

			if (HCD_Calcification_Level == (uint8)0)
			{
				if (max_calcification_level > (uint8)0) // Protection
				{
					HCD_Calcification_Level ++;
					calcification_level_increased = TRUE;

					// Don't update current_level_params_ptr, keep the current one
				}
			}

			manage_consistent_lockout_countdown = TRUE;
		}


 		// *** Consistent Lockout Countdown ***

		if ((uint8)manage_consistent_lockout_countdown == (uint8)TRUE)
		{
			uint8 cycles_remaining;

			// Calculate current value of cycles remaining
			if (HCD_Counters.Lockout_Counter < current_level_params_ptr->Lockout_Threshold)
			{
				cycles_remaining = current_level_params_ptr->Lockout_Threshold - HCD_Counters.Lockout_Counter;
			}
			else
			{
				cycles_remaining = 0;
			}

			if ((current_level_params_ptr->Lockout_Threshold > (uint8)0) && (cycles_remaining <= HCD_Lowest_Lockout_Thr))
			{
				if (HCD_Calcification_Level < max_calcification_level)
				{
					// Reset Lockout Counter if	CL != Max CL
					HCD_Counters.Lockout_Counter = 0;
					HCD_Calcification_Level = max_calcification_level;
					// Do not consider this HCD_Calcification_Level change to trigger WHS increase
				}
			}
		}

        // Update pointer to the set of parameters correspondent to the current HCD_Calcification_Level
		UpdateParamsPointerAndAlignCountersToThresholds(&current_level_params_ptr);

		// Update HCD_Counters.HCD_Counters.Cycles_Remaining with the last thresholds.
		if (HCD_Counters.Lockout_Counter < current_level_params_ptr->Lockout_Threshold)
		{
			HCD_Counters.Cycles_Remaining = current_level_params_ptr->Lockout_Threshold - HCD_Counters.Lockout_Counter;
		}
		else
		{
			HCD_Counters.Cycles_Remaining = 0;
		}

		// Manage Alarm Counter
	    if (current_level_params_ptr->Descale_Alarm_Threshold > (uint8)0)
	    {
			if (HCD_Counters.Alarm_Counter < current_level_params_ptr->Descale_Alarm_Threshold)
			{
		    	// Increase Alarm Counter
				HCD_Counters.Alarm_Counter ++;
			}
			else
			{
				// Set Alarm Counter to 1 if it exceeds current Threshold
				HCD_Counters.Alarm_Counter = 1;
			}
	    }
	    else
	    {
	    	// If a particular threshold equals zero, then any counter relying on this threshold should be kept at 0
	    	// and no events related to that threshold should be triggered.
	    }

	    // *** Periodic_HT Management ***
		if ((SF_HCD_Parameters->Periodic_HT_Threshold == (uint8)0) || (HCD_Counters.Periodic_HT_Counter > SF_HCD_Parameters->Periodic_HT_Threshold))
		{
			HCD_Counters.Periodic_HT_Counter = 0;
			HCD_Bitmap.Periodic_HT_Required = FALSE;
		}
		else
		{
			if (HCD_Reduction_Temperature >= ENDIANU16_STON(SF_HCD_Parameters->Periodic_HT_Min_Temperature))
			{
				HCD_Counters.Periodic_HT_Counter = 0;
				HCD_Bitmap.Periodic_HT_Required = FALSE;
			}
			else
			{
				if (HCD_Counters.Periodic_HT_Counter == SF_HCD_Parameters->Periodic_HT_Threshold)
				{
					if ((uint8)HCD_Bitmap.Periodic_HT_Required == (uint8)0)
					{
						HCD_Counters.Periodic_HT_Counter = 0;
					}
				}
				else
				{
					HCD_Counters.Periodic_HT_Counter ++;
					HCD_Bitmap.Periodic_HT_Required = FALSE;

					if (HCD_Counters.Periodic_HT_Counter == SF_HCD_Parameters->Periodic_HT_Threshold)
					{
						HCD_Bitmap.Periodic_HT_Required = TRUE;
					}
				}
			}
		}


		// *** Setup data for HMI ***
        HCD_HMI_Data.Flags.Descale_Icon_Mode = current_level_params_ptr->Descale_Icon_Mode;
        HCD_HMI_Data.Flags.Show_Descale = ((current_level_params_ptr->Descale_Alarm_Threshold > (uint8)0) &&
                                           ((current_level_params_ptr->Descale_Alarm_Threshold == (uint8)1) || (HCD_Counters.Alarm_Counter == (uint8)2))) ? (TRUE) : (FALSE);
        HCD_HMI_Data.Flags.Lockout = ((current_level_params_ptr->Lockout_Threshold > (uint8)0) && (HCD_Counters.Lockout_Counter >= current_level_params_ptr->Lockout_Threshold)) ? (TRUE) : (FALSE);
        HCD_HMI_Data.Cycles_Remaining = HCD_Counters.Cycles_Remaining;
        HCD_HMI_Data.Flags.Show_Countdown = (((uint8)HCD_HMI_Data.Flags.Show_Descale != (uint8)0) &&
                                           (HCD_HMI_Data.Cycles_Remaining > (uint8)0) && (HCD_HMI_Data.Cycles_Remaining <= HCD_Lowest_Lockout_Thr)) ? (TRUE) : (FALSE);

        if ((uint8)calcification_level_increased == (uint8)TRUE)
        {
            sint32 salt_alarm_led;
            REGULATIONS_CONFIG_TYPE *reg_config_ptr = Regulations__GetRegulationConfig(WHS_Function_Position);

            if (((uint8)Variable__GetValue(VARIABLE_SALT_ALARM_LED, 0, &salt_alarm_led) == (uint8)TRUE) && (reg_config_ptr != NULL) &&
                (Regulations__IsRegulationChanged(WHS_Function_Position) == FALSE))
            {

                if ((salt_alarm_led == (SALT_ALARM_LED_STATE_TYPE)SALT_ALARM_LED_STATE_OFF) && (HCD_WHS_Increased_By < SF_HCD_Parameters->WHS_Max_Increase) &&
                        (Regulations__GetIndexValueByPosition(WHS_Function_Position) < reg_config_ptr->Num_Regulations))
                {
                    increase_WHS = TRUE;
                    HCD_WHS_Increased_By ++;
                }
            }
            else
            {
                // Do nothing in any of the following cases:
                // 1. it is not possible to retrieve the Salt Alarm Led status;
                // 2. it is not possible to retrieve the WHS function configuration (e.g.: the function is not present in setting file);
                // 3. there is a pending regulation change on WHS function: in this cases priority is given to the HMI request.
            }
        }

        HCD_HMI_Data.Flags.Increase_WHS = ((uint8)increase_WHS == (uint8)TRUE) ? (TRUE) : (FALSE);

        if (HCD_HMI_Data.Flags.Descale_Icon_Mode != (uint8)0)
        {
            StatisticsDish__IncreaseCyclesWithLimescale();
        }
    }
}


BOOL_TYPE HeaterCalcificationDetectionMonitor__GetLockoutStatus(void)
{
	return (((uint8)HCD_HMI_Data.Flags.Lockout == (uint8)0) ? (FALSE) : (TRUE));
}

//=====================================================================================================================
//-------------------------------------- Private Functions ------------------------------------------------------------
//=====================================================================================================================

//----------------------------------------------------------------------------
/**
 *  @brief      HeaterCalcificationDetectionModelSetup
 *  @details    Function used to initialize and setup the model.
 *
 */
static void HeaterCalcificationDetectionModelSetup(void)
{    
    /* Pack model data into RTM */
	HeaterCalcificationDetection_RTModelData->dwork = &HeaterCalcificationDetection_ObservableStates;
            
	// Initialize model
	HeaterCalcificationDetectionMaster__Initialize(HeaterCalcificationDetection_RTModelData);
}


/*
 * Calculates temperature thresholds array (one element for each Calcification Level) using linear interpolation between the values in setting file.
 *
 * @param input_current = value of heater current used as input for the interpolation
 * @param interpolated_thresholds = pointer to the array of interpolated thresholds

 */
static void TemperatureThresholdsInterpolation(uint16 input_current, uint16 *interpolated_thresholds)
{
	uint8 heater_current_index;
	uint8 level_index;

	heater_current_index = 0;

	while ((heater_current_index < HEATER_CURRENT_THRESHOLDS_NUM) && (input_current > ENDIANU16_STON(SF_HCD_Parameters->Heater_Current_i[heater_current_index])))
	{
		heater_current_index ++;
	}

	if (heater_current_index == (uint8)0)
	{
		// Special case: input_current <= SF_HCD_Parameters->Heater_Current_i[0]
		heater_current_index = 1;
		input_current = ENDIANU16_STON(SF_HCD_Parameters->Heater_Current_i[0]);
	}
	else if (heater_current_index == HEATER_CURRENT_THRESHOLDS_NUM)
	{
		// Special case: input_current > SF_HCD_Parameters->Heater_Current_i[5]
		heater_current_index = 5;
		input_current = ENDIANU16_STON(SF_HCD_Parameters->Heater_Current_i[5]);
	}
	else
	{
		// Do nothing
	}

	for (level_index = 0; level_index < SF_Calcification_Levels_Number; level_index ++)
	{
		const HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE *current_level_params_ptr = SF_HCD_Lvl_Parameters + level_index;;
		uint16 temp_thresh_min = ENDIANU16_STON(current_level_params_ptr->Temperature_for_Heater_Power[heater_current_index - (uint8)1]);
		uint16 temp_thresh_max = ENDIANU16_STON(current_level_params_ptr->Temperature_for_Heater_Power[heater_current_index]);
		uint16 current_thres_min = ENDIANU16_STON(SF_HCD_Parameters->Heater_Current_i[heater_current_index - (uint8)1]);
		uint16 current_thres_max = ENDIANU16_STON(SF_HCD_Parameters->Heater_Current_i[heater_current_index]);

		if ((current_thres_max - current_thres_min) != (uint16)0)
		{
			*(interpolated_thresholds + level_index) = (uint16)(temp_thresh_min + (((temp_thresh_max - temp_thresh_min) * (input_current - current_thres_min)) /(current_thres_max - current_thres_min)));
		}
		else
		{
			*(interpolated_thresholds + level_index) = temp_thresh_min;
		}
	}
}


/*
 * Update the pointer to the set of parameters correspondent to the current HCD_Calcification_Level
 * If HCD_Counters.Alarm_Counter, HCD_Counters.Reduction_Counter or HCD_Counters.Lockout_Counter exceeds their respective
 * thresholds, the counters are aligned to the threshold' value. It implies resetting the counter if threshold equals 0.
 *
 * @param current_level_params_ptr = pointer to the set of parameters correspondent to the current HCD_Calcification_Level

 */
static void UpdateParamsPointerAndAlignCountersToThresholds(const HEATER_CALCIFICATION_LEVEL_DIP_PARAMS_TYPE **current_level_params_ptr)
{
    // Update pointer to the set of parameters correspondent to the current HCD_Calcification_Level
   *current_level_params_ptr = SF_HCD_Lvl_Parameters + HCD_Calcification_Level;

    if (HCD_Counters.Alarm_Counter > (*current_level_params_ptr)->Descale_Alarm_Threshold)
	{
		HCD_Counters.Alarm_Counter = (*current_level_params_ptr)->Descale_Alarm_Threshold;
	}

	if (HCD_Counters.Reduction_Counter > (*current_level_params_ptr)->Calcification_Reduction_Threshold)
	{
		HCD_Counters.Reduction_Counter = (*current_level_params_ptr)->Calcification_Reduction_Threshold;
	}

	if (HCD_Counters.Lockout_Counter > (*current_level_params_ptr)->Lockout_Threshold)
	{
		HCD_Counters.Lockout_Counter = (*current_level_params_ptr)->Lockout_Threshold;
	}
}
