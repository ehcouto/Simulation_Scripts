/**
 *  @file		AirlockMonitor.c
 *
 *  @brief      Wrapper for the code generated Airlock_Model
 *
 *  @details    This code has the monitor initialize and execution interfaces, also an enabling/disabling function
 *  			as Start/Stop, and a Reset function to clear the model information.
 *
 *  @section    Applicable_Documents
 *					List here all the applicable documents if needed. <tr>
 *
 *  $Header: $
 *
 *  @copyright  Copyright 2018-2019. Whirlpool Corporation. All rights reserved - CONFIDENTIAL
 */
//---------------------------------------------------------------------------------------------------------------------
//---------------------------------------------------------------------------------------------------------------------


//-------------------------------------- Include Files ----------------------------------------------------------------
#include "AirlockMonitor.h"
#include "Vwi.h"
#include "Log.h"

//-------------------------------------- PUBLIC (Variables) -----------------------------------------------------------
static AIRLOCK_STATUS_TYPE Airlock_Status = ALS_NONE;

//-------------------------------------- PRIVATE (Variables, Constants & Defines) -------------------------------------
//! Boolean variable to enable and disable airlock execution.
static BOOL_TYPE Airlock_Enabled = FALSE;

//! Pointer to the setting file data.
static AIRLOCK_PARAMS_TYPE* Sf_AirlockData_Ptr;

//! Setting file data structure.
static AIRLOCK_PARAMS_TYPE Sf_AirlockData;

//! The name of this module for use by the Log module.
#define MODULE_NAME MODULE_AIRLOCK_MONITOR

//! A list of log message IDs that are generated by this module.
typedef enum MODULE_AIRLOCK_MONITOR_LOG_MESSAGE_ID_ENUM
{
	ERROR_LOADING_PARAMETERS       = 1,
} MODULE_AIRLOCK_MONITOR_LOG_MESSAGE_ID_TYPE;

//-------------------------------------- PRIVATE (Function Prototypes) ------------------------------------------------

//=====================================================================================================================
//-------------------------------------- Public Functions -------------------------------------------------------------
//=====================================================================================================================

//----------------------------------------------------------------------------
/**
 *  @brief      AirlockMonitor__Initialize
 *  @details    Function used to initialize the airlock monitor.
 *
 */
void AirlockMonitor__Initialize()
{

	// Initialize Model
	AirlockModel__Initialize();

    // Initialize SF data pointer
	Sf_AirlockData_Ptr = NULL;


	// Load parameters from setting file
	SETTINGFILE_LOADER_TYPE loader;
	if (SettingFile__BasicLoader(SF_PTR_ACU_ALGORITHM_PARAMETERS, DISPL_AIRLOCK, &loader) == PASS)
	{
		Sf_AirlockData.VwiAirlockDelta = ENDIANU16_STON(((AIRLOCK_PARAMS_TYPE*)(void*)(loader.Data))->VwiAirlockDelta);
		Sf_AirlockData.VwiVarianceLowThold = ENDIANU16_STON(((AIRLOCK_PARAMS_TYPE*)(void*)(loader.Data))->VwiVarianceLowThold);
		Sf_AirlockData.VwiVarianceHighThold = ENDIANU16_STON(((AIRLOCK_PARAMS_TYPE*)(void*)(loader.Data))->VwiVarianceHighThold);
		Sf_AirlockData.AirlockRiskTimeout = ENDIANU16_STON(((AIRLOCK_PARAMS_TYPE*)(void*)(loader.Data))->AirlockRiskTimeout);
		if (loader.Length >= sizeof(AIRLOCK_PARAMS_TYPE))
		{
			Sf_AirlockData.VwiRecoveryDelta = ENDIANU16_STON(((AIRLOCK_PARAMS_TYPE*)(void*)(loader.Data))->VwiRecoveryDelta);
		}
		else
		{
			Sf_AirlockData.VwiRecoveryDelta = Sf_AirlockData.VwiAirlockDelta;
		}

		Sf_AirlockData_Ptr = &Sf_AirlockData;
	}
	else
	{
		LOG_ADD_EXCEPTION(ERROR_LOADING_PARAMETERS, SF_PTR_ACU_PRODUCT_CONFIGURATION_DATA);
	}
}

//----------------------------------------------------------------------------
/**
 *  @brief      AirlockMonitor__Execution
 *  @details    Function used to perform the airlock monitor.
 *
 */
void AirlockMonitor__Execution(void)
{
	uint16 vwi_signal;
	uint16 vwi_variance;

	if (Sf_AirlockData_Ptr != NULL)
	{
		// Monitor will run only when enabled
		if (Airlock_Enabled)
		{
			vwi_signal = Vwi__GetSignal();
			vwi_variance = Vwi__GetVariance();

			Airlock_Status = AirlockModel__Execute(vwi_signal, vwi_variance, Sf_AirlockData_Ptr);
		}
	}
//	else
//	{
//		AirlockMonitor__Initialize();
//	}
}

//---------------------------------------------------------------------------------------------------------------------
/**
 *  @brief		Function to return the Airlock_Status
 *
 */
AIRLOCK_STATUS_TYPE AirlockMonitor__GetStatus(void)
{
	return Airlock_Status;
}

//----------------------------------------------------------------------------
/**
 *  @brief      AirlockMonitor__Start
 *  @details    Function used to enable the airlock monitor.
 *
 */
void AirlockMonitor__Start(void)
{
	Airlock_Enabled = TRUE;
}

//----------------------------------------------------------------------------
/**
 *  @brief      AirlockMonitor__Stop
 *  @details    Function used to disable the airlock monitor.
 *
 */
void AirlockMonitor__Stop(void)
{
	Airlock_Enabled = FALSE;
}

//----------------------------------------------------------------------------
/**
 *  @brief      AirlockMonitor__Reset
 *  @details    Function used to reset the airlock monitor.
 *
 */
void AirlockMonitor__Reset(void)
{
	Airlock_Enabled = FALSE;	// Stop Model

	Airlock_Status = ALS_NONE;	// Reset Airlock_Status
	AirlockModel__Initialize(); // Initialize Model

	Airlock_Enabled = TRUE; 	// Restart Model
}

//=====================================================================================================================
//-------------------------------------- Private Functions ------------------------------------------------------------
//=====================================================================================================================


